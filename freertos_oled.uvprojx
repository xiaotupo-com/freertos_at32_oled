# Keil uVision project freertos_oled.uvprojx, settings and files
target template (6160000::V6.16::ARMCLANG)
  device: -AT32F413CCU7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_oled
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 wLevel=3
  c define: AT32F413CCU7,USE_STDPERIPH_DRIVER,AT_START_F413_V1
  c include: .\inc;.\libraries\drivers\inc;.\libraries\cmsis\cm4\device_support;.\libraries\cmsis\cm4\core_support;.\FreeRTOS-Kernel\include;.\middleware;.\FreeRTOS-Kernel\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./src/: at32f413_clock.c at32f413_int.c main.c xtp_defines.c xtp_gpio.c xtp_create_task.c
  group firmware
    ./libraries/cmsis/cm4/device_support/: system_at32f413.c
    ./libraries/drivers/src/: at32f413_misc.c at32f413_gpio.c at32f413_crm.c
  group cmsis
    ./libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f413.s
  group freertos
    ./FreeRTOS-Kernel/: tasks.c list.c
    ./FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ./FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
  group middleware
    ./middleware/: led.c xtp_cross_platform.c
